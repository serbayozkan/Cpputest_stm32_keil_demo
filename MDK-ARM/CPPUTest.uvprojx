# Keil uVision project CPPUTest.uvprojx, settings and files
target CPPUTest (6120000::V6.12::.\ARMCLANG)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: CPPUTest
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: -fexceptions
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;..\Middlewares\Third_Party\CPPUTEST\include;..\Middlewares\Third_Party\CPPUTEST\include\CppUTest;..\Middlewares\Third_Party\CPPUTEST\include\CppUTestExt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_i2c.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal.c stm32f7xx_hal_pwr.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f7xx.c
  group Application/User
    ../Src/: gpio.c stm32f7xx_hal_msp.c stm32f7xx_it.c main.cpp fputc_debug.c UnitTest.cpp
  group CPPUTEST Lib.
    ../Middlewares/Third_Party/CPPUTEST/src/CppUTest/: CommandLineArguments.cpp CommandLineTestRunner.cpp JUnitTestOutput.cpp MemoryLeakDetector.cpp MemoryLeakWarningPlugin.cpp SimpleMutex.cpp SimpleString.cpp TeamCityTestOutput.cpp TestFailure.cpp TestFilter.cpp TestHarness_c.cpp TestMemoryAllocator.cpp TestOutput.cpp TestPlugin.cpp TestRegistry.cpp TestResult.cpp TestTestingFixture.cpp Utest.cpp UtestPlatform.cpp
software components: CMSIS:CORE 5.2.0
